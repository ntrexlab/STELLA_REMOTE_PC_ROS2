Commit message: Update stella.urdf

File: stella_description/urdf/stella.urdf (robot description, URDF)
Before this commit: robot stella, 4 links, 3 joints
Joints:
- joint scan_joint: origin xyz=0.145 0.0 0.229 rpy=0.0 0.0 0.0 -> xyz=0.145 0.0 0.248 rpy=0.0 0.0 0.0
